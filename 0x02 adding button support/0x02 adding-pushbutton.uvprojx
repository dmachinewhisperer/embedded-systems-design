# Keil uVision project 0x02 adding-pushbutton.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0x02 adding-pushbutton
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:Startup 2.6.3
